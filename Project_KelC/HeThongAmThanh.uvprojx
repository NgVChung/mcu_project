# Keil uVision project HeThongAmThanh.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HeThongAmThanh +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM3210X_MD
  c include: ..\Lib\CMSIS\CM3\CoreSupport;..\app\inc;..\app\src;..\bsp;..\hal\inc;..\Lib\STM32F10x_StdPeriph_Driver\inc;..\Lib\STM32F10x_StdPeriph_Driver\src;..\middlewares\FreeRTOS\include;..\middlewares\FreeRTOS;..\middlewares\FreeRTOS\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group app
    ../app/src/: app_ipc.c audio_dsp.c task_adc.c task_button.c task_spi.c
    ../: main.c
  group bsp
    ../bsp/: bsp.c
  group hal
    ../hal/src/: hal_adc.c hal_gpio.c hal_spi.c
  group lib
    ../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group middlewares
    ../middlewares/FreeRTOS/: list.c queue.c tasks.c
    ../middlewares/FreeRTOS/portable/MemMang/: heap_4.c
    ../middlewares/FreeRTOS/portable/RVDS/ARM_CM3/: port.c
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
